FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://Fix_buildbreak_with_kdoctools.patch"
