
DEPENDS_append = " \
    kdoctools \
"
