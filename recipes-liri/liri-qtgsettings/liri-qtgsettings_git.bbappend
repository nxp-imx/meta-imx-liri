
RDEPENDS_${PN}_remove = "dconf"