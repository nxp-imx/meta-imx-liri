
DEPENDS_append = "libxcursor"
