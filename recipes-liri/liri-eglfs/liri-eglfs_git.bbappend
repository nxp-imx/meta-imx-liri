
SRC_URI_remove = "file://0001-qeglfskmsgbmscreen-remove-frame-recording-completely.patch"

SRCREV = "54534b5f544dde7726ecffbf800cf8fc7e6e66d7"