
RDEPENDS_${PN}_remove = " \
    ttf-devanagari \
    ttf-opensans \
    otf-noto \
    networkmanager \
"
