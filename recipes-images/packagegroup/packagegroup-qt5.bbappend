
RDEPENDS_${PN}_remove = " \
    qttranslations-qt \
    qtcanvas3d \
"
