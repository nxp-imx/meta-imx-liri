
RDEPENDS_${PN}_remove = " \
    adbd \
    networkmanager-adsl \
    networkmanager-openvpn \
    networkmanager-nmtui \
"
