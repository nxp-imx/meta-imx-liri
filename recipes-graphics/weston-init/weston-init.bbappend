
do_install_appen () {
    rm -f ${D}${sysconfdir}/udev/rules.d/71-weston-drm.rules
}
