
SRC_URI_remove = "file://0002-qdbusxml2cpp-prepare-commandline-string-manipulation.patch"
